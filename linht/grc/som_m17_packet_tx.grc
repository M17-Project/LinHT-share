options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_m17_packet_tx
    output_language: python
    run_options: run
    title: M17 packet transmit
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: int(0.04*4800)
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*math.pi*800.0)/samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: bsb_sink
    num_inputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/m17_packet_symbols
    repeat: 'False'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: zmq_len
    type: float
  states: {}
- name: bsb_sink
  id: parameter
  parameters:
    label: Baseband sink  device
    short_id: b
    type: str
    value: hw:SX1255,1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '500'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: '81'
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: ipc:///tmp/m17_symbols_tx
    bind: 'True'
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', rational_resampler_xxx_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_file_source_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_vector_to_stream_0, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
