options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_zmq_test_tx
    output_language: python
    run_options: run
    title: Test ZMQ transmitter
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: zmq_addr
  id: variable
  parameters:
    value: '"10.17.17.1"'
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: bsb_sink
    num_inputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: 2**11
    type: complex
  states: {state: disabled}
- name: bsb_sink
  id: parameter
  parameters:
    label: Baseband sink device
    short_id: b
    type: str
    value: hw:SX1255,1
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://"+zmq_addr+":17001"'
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
