options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2026
    generate_options: no_gui
    id: som_mpeg_test_tx
    output_language: python
    run_options: run
    title: Test MPEG-TS tranmitter
  states: {}

blocks:
- name: qam_constellation
  id: variable_constellation
  parameters:
    const_points: '[-1. -1.j, -1. -0.71428571j, -1. -0.14285714j, -1. -0.42857143j, -1. +1.j, -1. +0.71428571j, -1. +0.14285714j, -1. +0.42857143j, -0.71428571-1.j, -0.71428571-0.71428571j, -0.71428571-0.14285714j, -0.71428571-0.42857143j, -0.71428571+1.j, -0.71428571+0.71428571j, -0.71428571+0.14285714j, -0.71428571+0.42857143j, -0.14285714-1.j, -0.14285714-0.71428571j, -0.14285714-0.14285714j, -0.14285714-0.42857143j, -0.14285714+1.j, -0.14285714+0.71428571j, -0.14285714+0.14285714j, -0.14285714+0.42857143j, -0.42857143-1.j, -0.42857143-0.71428571j, -0.42857143-0.14285714j, -0.42857143-0.42857143j, -0.42857143+1.j, -0.42857143+0.71428571j, -0.42857143+0.14285714j, -0.42857143+0.42857143j, 1. -1.j, 1. -0.71428571j, 1. -0.14285714j, 1. -0.42857143j, 1. +1.j, 1. +0.71428571j, 1. +0.14285714j, 1. +0.42857143j, 0.71428571-1.j, 0.71428571-0.71428571j, 0.71428571-0.14285714j, 0.71428571-0.42857143j, 0.71428571+1.j, 0.71428571+0.71428571j, 0.71428571+0.14285714j, 0.71428571+0.42857143j, 0.14285714-1.j, 0.14285714-0.71428571j, 0.14285714-0.14285714j, 0.14285714-0.42857143j, 0.14285714+1.j, 0.14285714+0.71428571j, 0.14285714+0.14285714j, 0.14285714+0.42857143j, 0.42857143-1.j, 0.42857143-0.71428571j, 0.42857143-0.14285714j, 0.42857143-0.42857143j, 0.42857143+1.j, 0.42857143+0.71428571j, 0.42857143+0.14285714j, 0.42857143+0.42857143j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    sym_map: np.arange(64)
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: 255+1
    minimum: '0'
    seed: '73'
    type: byte
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: bsb_sink
    num_inputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_offs
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: samples/sample_1280x720_surfing_with_audio.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '6'
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    comment: |-
      1 "sync" frame
      200 MPEG-TS frames
    lengths: (4, 184, 200*188)
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    comment: MPEG-TS null packet header
    repeat: 'True'
    type: byte
    vector: (0x47, 0x1F, 0xFF, 0x10)
    vlen: '4'
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '4'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {state: disabled}
- name: bsb_sink
  id: parameter
  parameters:
    label: Baseband sink device
    short_id: b
    type: str
    value: hw:SX1255,1
  states: {}
- name: dc_offs
  id: parameter
  parameters:
    label: IQ DC ofset
    short_id: d
    type: complex
    value: 0+0j
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qam_constellation
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[0.004562185464, -0.003315159603, 0.004494660764, -0.005933215824, 0.007662642297, -0.009730151262, 0.012163462902, -0.015021624093, 0.018344736003, -0.022179571087, 0.026587935938, -0.031624350959, 0.037349001966, -0.043825719260, 0.051125585868, -0.059326237377, 0.068504390315, -0.078746186598, 0.090147725138, -0.102813489566, 0.116858526852, -0.132408962019, 0.149609118181, -0.168623734209, 0.189641904748, -0.212886091306, 0.238618491973, -0.267152027409, 0.298864858677, -0.334221364400, 0.373800820471, -0.418331953197, 0.468744199982, -0.526240588097, 0.592399581386, -0.669319857641, 0.759823522591, -0.867734659884, 0.998215908414, -1.158013367129, 1.354923496534, -1.593658456679, 1.856602265650, -2.021519762741, 1.526746272983, 1.526746272983, -2.021519762741, 1.856602265650, -1.593658456679, 1.354923496534, -1.158013367129, 0.998215908414, -0.867734659884, 0.759823522591, -0.669319857641, 0.592399581386, -0.526240588097, 0.468744199982, -0.418331953197, 0.373800820471, -0.334221364400, 0.298864858677, -0.267152027409, 0.238618491973, -0.212886091306, 0.189641904748, -0.168623734209, 0.149609118181, -0.132408962019, 0.116858526852, -0.102813489566, 0.090147725138, -0.078746186598, 0.068504390315, -0.059326237377, 0.051125585868, -0.043825719260, 0.037349001966, -0.031624350959, 0.026587935938, -0.022179571087, 0.018344736003, -0.015021624093, 0.012163462902, -0.009730151262, 0.007662642297, -0.005933215824, 0.004494660764, -0.003315159603, 0.004562185464]'
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.2'
    gain: sps*0.25
    interp: sps
    ntaps: '101'
    samp_rate: sps
    sym_rate: '1'
    type: interp_fir_filter_ccf
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.17.17.1:17005
    timeout: '100'
    type: complex
    vlen: '2048'
  states: {state: disabled}

connections:
- [analog_random_uniform_source_x_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_file_source_0_0, '0', blocks_stream_mux_0_0, '2']
- [blocks_repack_bits_bb_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_vector_source_x_1, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_complex_to_float_0, '0']
- [digital_constellation_encoder_bc_0, '0', root_raised_cosine_filter_1, '0']
- [fir_filter_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [root_raised_cosine_filter_1, '0', rational_resampler_xxx_0, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
