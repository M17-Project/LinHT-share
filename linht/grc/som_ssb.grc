options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_ssb
    output_language: python
    run_options: run
    title: LinHT SSB transceiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    comment: Baseband output
    device_name: hw:SX1255,1
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    comment: Audio output
    device_name: hw:wm8960audio
    samp_rate: '8000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: Microphone input
    device_name: hw:wm8960audio
    samp_rate: '8000'
  states: {}
- name: audio_source_0_0
  id: audio_source
  parameters:
    comment: Baseband input
    device_name: hw:SX1255
    num_outputs: '2'
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: inp_gain
    high_cutoff_freq: '3700'
    low_cutoff_freq: '100'
    samp_rate: 8e3
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: USB/LSB switch
    decim: '1'
    gain: '1'
    high_cutoff_freq: 3700-(1-ssb)*3800
    low_cutoff_freq: 100-(1-ssb)*3800
    samp_rate: '8000'
    type: fir_filter_ccc
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: iq_dc
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (2*ssb-1) * (1+iq_bal)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1-iq_bal
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: np.cos(iq_angle/180*np.pi) + np.sin(iq_angle/180*np.pi)*1j
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '101'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: inp_gain
  id: parameter
  parameters:
    label: Input gain
    short_id: g
    type: eng_float
    value: '0.1'
  states: {}
- name: iq_angle
  id: parameter
  parameters:
    label: IQ angle (degrees)
    short_id: t
    type: eng_float
    value: '0'
  states: {}
- name: iq_bal
  id: parameter
  parameters:
    label: IQ balance
    short_id: b
    type: eng_float
    value: '0'
  states: {}
- name: iq_dc
  id: parameter
  parameters:
    label: IQ DC offset
    short_id: d
    type: complex
    value: '0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Channelizer
      (pass both sidebands)
    cutoff_freq: '3700'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '300'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '500'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '8'
    type: ccc
  states: {state: disabled}
- name: ssb
  id: parameter
  parameters:
    comment: |-
      Sideband selection:
      0 - LSB
      1 - USB (default)
    label: Sideband
    short_id: s
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [audio_source_0, '0', band_pass_filter_0, '0']
- [audio_source_0_0, '0', blocks_float_to_complex_1, '0']
- [audio_source_0_0, '1', blocks_float_to_complex_1, '1']
- [band_pass_filter_0, '0', hilbert_fc_0, '0']
- [band_pass_filter_1, '0', blocks_complex_to_float_1_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0_0, '1']
- [blocks_complex_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_1, '1', blocks_multiply_const_vxx_0_0, '0']
- [blocks_complex_to_float_1_0, '0', audio_sink_0_0_0, '0']
- [blocks_complex_to_float_1_0, '1', blocks_null_sink_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_float_to_complex_1, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_float_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [rational_resampler_xxx_1, '0', band_pass_filter_1, '0']
- [virtual_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
