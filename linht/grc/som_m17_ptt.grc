options:
  parameters:
    author: Wojciech SP5WWP, Andreas OE3ANC
    copyright: M17 Foundation 2026
    generate_options: no_gui
    id: som_m17_ptt
    output_language: python
    run_options: run
    title: Sample M17 transceiver with PTT via ZMQ
  states: {}

blocks:
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 6e3
    gain: '1.0'
    samp_rate: rf_samp_rate
    width: 6.25e3/2
    win: window.WIN_HAMMING
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: int(125e3)
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.5'
    gain: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*np.pi*800.0)/48e3
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 12.5e3/(2.0*math.pi*800.0)
  states: {}
- name: audio_dev
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: hw:wm8960audio
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: audio_dev
    samp_rate: '48000'
  states: {}
- name: audio_source_1
  id: audio_source
  parameters:
    device_name: audio_dev
    maxoutbuf: '4800'
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_offs
    type: complex
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    type: int
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: 2**31
  states: {}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: 2**31
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: int
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(48/8)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (0.5 + 0j)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_stream_to_vector_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: int
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: zmq_len
    type: int
  states: {}
- name: can
  id: parameter
  parameters:
    label: M17 CAN
    short_id: C
    type: intx
    value: '0'
  states: {}
- name: dc_offs
  id: parameter
  parameters:
    label: IQ DC offset
    short_id: o
    type: complex
    value: '0'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '10'
    init_phase: '5'
    loop_bw: 2*math.pi*0.0015
    max_dev: '0.05'
    osps: '1'
    sps: '10'
    taps: rrc_taps
    type: fff
  states: {}
- name: dst
  id: parameter
  parameters:
    label: M17 DST address
    short_id: D
    type: str
    value: '@ALL'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: (1, -0.999)
    fftaps: (1, -1)
    oldstyle: 'False'
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3600'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: can
    debug: 'False'
    dst_id: dst
    encr_subtype: '0'
    encr_type: '0'
    eot_cnt: '1'
    key: ''
    meta: ''
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src
    type: '2'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'False'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    sw_threshold: '2.0'
    vt_threshold: '30.0'
  states: {}
- name: pfb_decimator_ccf_0
  id: pfb_decimator_ccf
  parameters:
    atten: '60'
    channel: '0'
    decim: '10'
    fft_rot: 'False'
    taps: lpf_taps
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    fbw: '0.4'
    interp: '480'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '125'
    type: ccf
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '48'
    type: fff
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: src
  id: parameter
  parameters:
    label: M17 SRC address
    short_id: S
    type: str
    value: L1NHT
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: ipc:///tmp/fg_aux_data_out
    timeout: '100'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/bsb_tx
    bind: 'False'
    timeout: '100'
    type: int
    vlen: '2048'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: ipc:///tmp/ptt_msg
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: ipc:///tmp/bsb_rx
    timeout: '100'
    type: int
    vlen: zmq_len
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', rational_resampler_xxx_1, '0']
- [audio_source_1, '0', low_pass_filter_1, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_int_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_int_0_0, '0']
- [blocks_deinterleave_0, '0', blocks_int_to_float_0, '0']
- [blocks_deinterleave_0, '1', blocks_int_to_float_0_0, '0']
- [blocks_float_to_complex_0, '0', pfb_decimator_ccf_0, '0']
- [blocks_float_to_int_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_int_0_0, '0', blocks_interleave_0, '1']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_int_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_int_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_vector_3, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_2, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_1, '0']
- [blocks_stream_to_vector_2, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_stream_to_vector_3, '0', zeromq_pub_sink_2, '0']
- [blocks_unpacked_to_packed_xx_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_deinterleave_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_stream_to_vector_0_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', m17_m17_decoder_0, '0']
- [iir_filter_xxx_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [iir_filter_xxx_0, '0', blocks_stream_to_vector_1, '0']
- [low_pass_filter_1, '0', blocks_keep_one_in_n_0, '0']
- [m17_m17_coder_0, '0', root_raised_cosine_filter_1_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [m17_m17_decoder_0, fields, zeromq_pub_msg_sink_0, in]
- [pfb_decimator_ccf_0, '0', iir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_stream_to_vector_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_1_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_msg_source_0, out, m17_m17_coder_0, transmission_control]
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
