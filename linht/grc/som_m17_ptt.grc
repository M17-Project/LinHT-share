options:
  parameters:
    author: Wojciech SP5WWP / Andreas OE3ANC
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_m17_ptt
    output_language: python
    run_options: run
    title: Sample M17 receiver with PTT via ZMQ
  states: {}

blocks:
- name: rf_samp_rate
  id: variable
  parameters:
    value: int(500e3)
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analog_frequency_modulator_fc_0_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2.0*np.pi*800.0)/48e3
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*math.pi*800.0)
  states: {state: disabled}
- name: audio_dev
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: hw:wm8960audio
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    device_name: '"hw:SX1255"'
    num_inputs: '2'
    samp_rate: rf_samp_rate
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    device_name: audio_dev
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"hw:SX1255"'
    num_outputs: '2'
    ok_to_block: 'False'
    samp_rate: rf_samp_rate
  states: {state: disabled}
- name: audio_source_1
  id: audio_source
  parameters:
    device_name: audio_dev
    maxoutbuf: '4800'
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: dc_offs
    type: complex
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_int_0
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_float_to_int_0_0
  id: blocks_float_to_int
  parameters:
    scale: 2**31
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: int
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(48/8)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (0.5 + 0j)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: int
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '500000'
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '64'
    type: byte
  states: {}
- name: can
  id: parameter
  parameters:
    label: M17 CAN
    short_id: C
    type: intx
    value: '0'
  states: {}
- name: dc_offs
  id: parameter
  parameters:
    label: IQ DC offset
    short_id: o
    type: complex
    value: '0'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.00015
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {state: disabled}
- name: dst
  id: parameter
  parameters:
    label: M17 DST address
    short_id: D
    type: str
    value: '@ALL'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[ 3.45379446e-06, -7.44373709e-06, 1.99382256e-05, -4.25078410e-05, 7.77895351e-05, -1.29448329e-04, 2.02125473e-04, -3.01367617e-04, 4.33530620e-04, -6.05651323e-04, 8.25279728e-04, -1.10026470e-03, 1.43848622e-03, -1.84752771e-03, 2.33428252e-03, -2.90448953e-03, 3.56219121e-03, -4.30910950e-03, 5.14393070e-03, -6.06148940e-03, 7.05183452e-03, -8.09915382e-03, 9.18051571e-03, -1.02643725e-02, 1.13087301e-02, -1.22588495e-02, 1.30442672e-02, -1.35748140e-02, 1.37351298e-02, -1.33769015e-02, 1.23075641e-02, -1.02734459e-02, 6.93396394e-03, -1.82104185e-03, -5.72659762e-03, 1.66732917e-02, -3.24770538e-02, 5.54343300e-02, -8.93342343e-02, 1.40769976e-01, -2.21934464e-01, 3.56985825e-01, -5.97442725e-01, 1.06000478e+00, -1.99968683e+00, 3.63384209e+00, -1.99968683e+00, 1.06000478e+00, -5.97442725e-01, 3.56985825e-01, -2.21934464e-01, 1.40769976e-01, -8.93342343e-02, 5.54343300e-02, -3.24770538e-02, 1.66732917e-02, -5.72659762e-03, -1.82104185e-03, 6.93396394e-03, -1.02734459e-02, 1.23075641e-02, -1.33769015e-02, 1.37351298e-02, -1.35748140e-02, 1.30442672e-02, -1.22588495e-02, 1.13087301e-02, -1.02643725e-02, 9.18051571e-03, -8.09915382e-03, 7.05183452e-03, -6.06148940e-03, 5.14393070e-03, -4.30910950e-03, 3.56219121e-03, -2.90448953e-03, 2.33428252e-03, -1.84752771e-03, 1.43848622e-03, -1.10026470e-03, 8.25279728e-04, -6.05651323e-04, 4.33530620e-04, -3.01367617e-04, 2.02125473e-04, -1.29448329e-04, 7.77895351e-05, -4.25078410e-05, 1.99382256e-05, -7.44373709e-06, 3.45379446e-06]'
    type: ccf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: rf_samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3600'
    decim: '1'
    gain: '1'
    samp_rate: '48000'
    type: fir_filter_fff
    width: '400'
    win: window.WIN_HAMMING
  states: {}
- name: m17_m17_coder_0
  id: m17_m17_coder
  parameters:
    aes_subtype: '0'
    can: can
    debug: 'False'
    dst_id: dst
    encr_subtype: '0'
    encr_type: '0'
    key: ''
    meta: ''
    mode: '1'
    priv_key: ''
    seed: ''
    signed_str: 'False'
    src_id: src
    type: '2'
  states: {}
- name: m17_m17_decoder_0
  id: m17_m17_decoder
  parameters:
    callsign: 'True'
    debug_ctrl: 'False'
    debug_data: 'True'
    encr_type: '0'
    key: ''
    seed: ''
    signed_str: 'False'
    sw_threshold: '2.0'
    vt_threshold: '30.0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '500'
    type: ccf
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '8'
    interp: '48'
    type: fff
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {state: disabled}
- name: root_raised_cosine_filter_1_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    gain: '10'
    interp: '10'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: interp_fir_filter_fff
  states: {}
- name: src
  id: parameter
  parameters:
    label: M17 SRC address
    short_id: S
    type: str
    value: L1NHT
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod
  states: {state: disabled}
- name: vocoder_codec2_decode_ps_0
  id: vocoder_codec2_decode_ps
  parameters:
    mode: codec2.MODE_3200
  states: {state: disabled}
- name: vocoder_codec2_encode_sp_0
  id: vocoder_codec2_encode_sp
  parameters:
    mode: codec2.MODE_3200
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_1
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {state: disabled}
- name: zeromq_pub_sink_2
  id: zeromq_pub_sink
  parameters:
    address: ipc:///tmp/bsb_tx
    bind: 'False'
    timeout: '100'
    type: int
    vlen: '2048'
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: ipc:///tmp/ptt_msg
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_noise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [audio_source_1, '0', low_pass_filter_1, '0']
- [blocks_add_const_vxx_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_complex_to_float_0_0, '0', audio_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_int_0, '0']
- [blocks_complex_to_float_0_0, '1', audio_sink_0_0, '1']
- [blocks_complex_to_float_0_0, '1', blocks_float_to_int_0_0, '0']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_correctiq_0, '0', low_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', blocks_null_sink_1, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_float_to_int_0, '0', blocks_interleave_0, '0']
- [blocks_float_to_int_0_0, '0', blocks_interleave_0, '1']
- [blocks_float_to_short_0, '0', vocoder_codec2_encode_sp_0, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_3, '0']
- [blocks_keep_one_in_n_0, '0', blocks_float_to_short_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_short_to_float_0, '0', rational_resampler_xxx_2, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [blocks_stream_to_vector_0_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_1, '0']
- [blocks_stream_to_vector_2, '0', vocoder_codec2_decode_ps_0, '0']
- [blocks_stream_to_vector_3, '0', zeromq_pub_sink_2, '0']
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', m17_m17_coder_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_stream_to_vector_0_0, '0']
- [digital_symbol_sync_xx_0, '0', m17_m17_decoder_0, '0']
- [fir_filter_xxx_0, '0', blocks_correctiq_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1, '0', blocks_keep_one_in_n_0, '0']
- [m17_m17_coder_0, '0', root_raised_cosine_filter_1_0, '0']
- [m17_m17_decoder_0, '0', blocks_null_sink_0, '0']
- [m17_m17_decoder_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_complex_to_float_0_0, '0']
- [rational_resampler_xxx_2, '0', audio_sink_1, '0']
- [root_raised_cosine_filter_0, '0', blocks_stream_to_vector_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_1_0, '0', analog_frequency_modulator_fc_0_0, '0']
- [virtual_source_0, '0', digital_symbol_sync_xx_0, '0']
- [vocoder_codec2_decode_ps_0, '0', blocks_short_to_float_0, '0']
- [vocoder_codec2_encode_sp_0, '0', blocks_vector_to_stream_0, '0']
- [zeromq_sub_msg_source_0, out, m17_m17_coder_0, transmission_control]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
