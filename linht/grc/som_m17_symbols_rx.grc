options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_m17_symbols_rx
    output_language: python
    run_options: run
    title: M17 symbol receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48e3/(2.0*math.pi*800.0)
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: bsb_source
    num_outputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fpath
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: bsb_source
  id: parameter
  parameters:
    label: Baseband source  device
    short_id: b
    type: str
    value: hw:SX1255
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: 2*math.pi*0.00015
    max_dev: '0.005'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '10'
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from scipy.signal import firwin2, lfilter

      #granularity
      N = 1000

      class firwin2_filter(gr.sync_block):
          def __init__(self, length=91, sinc_exp=1.0, sinc_gain=110.0, sinc_ratio=0.125):
              gr.sync_block.__init__(self,
                  name="Sinc Compensating Filter",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              self.length, self.sinc_exp, self.sinc_gain, self.sinc_ratio = length, sinc_exp, sinc_gain, sinc_ratio
              self.freq = np.linspace(0.0, 1.0, N)
              self.ampl = np.zeros(N)
              self.update_taps()
              self.zi_r = np.zeros(len(self.taps)-1, dtype=np.float32)
              self.zi_i = np.zeros(len(self.taps)-1, dtype=np.float32)   

          def update_taps(self):
              for i in range(N-1):
                  self.ampl[i] = pow(1 + pow((1 - np.sinc(i/(N-1) * self.sinc_ratio)), self.sinc_exp), self.sinc_gain)
              self.ampl[N-1] = 0
              self.taps = firwin2(self.length, self.freq, self.ampl, window='blackmanharris').astype(np.float32)
              
          #the set_* functions below do not actually make the parameters runtime adjustable :(
          def set_length(self, length):
              self.length = length
              self.update_taps()
              self.zi_r = np.zeros(len(self.taps)-1, dtype=np.float32)
              self.zi_i = np.zeros(len(self.taps)-1, dtype=np.float32)

          def set_sinc_exp(self, sinc_exp):
              self.sinc_exp = sinc_exp
              self.update_taps()

          def set_sinc_gain(self, sinc_gain):
              self.sinc_gain = sinc_gain
              self.update_taps()

          def set_sinc_ratio(self, sinc_ratio):
              self.sinc_ratio = sinc_ratio
              self.update_taps()

          def work(self, input_items, output_items):
              x = input_items[0]
              y_r, self.zi_r = lfilter(self.taps, 1.0, x.real, zi=self.zi_r)
              y_i, self.zi_i = lfilter(self.taps, 1.0, x.imag, zi=self.zi_i)
              output_items[0][:] = y_r + 1j * y_i
              return len(output_items[0])
    length: '91'
    sinc_exp: '1.0'
    sinc_gain: '110'
    sinc_ratio: '0.125'
  states: {}
- name: fpath
  id: parameter
  parameters:
    label: Symbol sink file
    short_id: f
    type: str
    value: '"/tmp/symbols"'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 6.25e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 6.25e3
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '500'
    interp: '48'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.5'
    decim: '1'
    gain: '1'
    ntaps: 8*10+1
    samp_rate: '10'
    sym_rate: '1'
    type: fir_filter_fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: baseband
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: baseband
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_correctiq_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_1, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_0, '0']
- [epy_block_1, '0', blocks_correctiq_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [virtual_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
