options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_zmq_test_rx
    output_language: python
    run_options: run
    title: Test ZMQ receiver
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: zmq_len
  id: variable
  parameters:
    value: 2**11
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: bsb_source
    num_outputs: '2'
    samp_rate: '500000'
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: complex
  states: {}
- name: bsb_source
  id: parameter
  parameters:
    label: Baseband source  device
    short_id: b
    type: str
    value: hw:SX1255
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      from scipy.signal import firwin2, lfilter

      #granularity
      N = 1000

      class firwin2_filter(gr.sync_block):
          def __init__(self, length=91, sinc_exp=1.0, sinc_gain=110.0, sinc_ratio=0.125):
              gr.sync_block.__init__(self,
                  name="Sinc Compensating Filter",
                  in_sig=[np.complex64],
                  out_sig=[np.complex64])
              self.length, self.sinc_exp, self.sinc_gain, self.sinc_ratio = length, sinc_exp, sinc_gain, sinc_ratio
              self.freq = np.linspace(0.0, 1.0, N)
              self.ampl = np.zeros(N)
              self.update_taps()
              self.zi_r = np.zeros(len(self.taps)-1, dtype=np.float32)
              self.zi_i = np.zeros(len(self.taps)-1, dtype=np.float32)   

          def update_taps(self):
              for i in range(N-1):
                  self.ampl[i] = pow(1 + pow((1 - np.sinc(i/(N-1) * self.sinc_ratio)), self.sinc_exp), self.sinc_gain)
              self.ampl[N-1] = 0
              self.taps = firwin2(self.length, self.freq, self.ampl, window='blackmanharris').astype(np.float32)
              
          #the set_* functions below do not actually make the parameters runtime adjustable :(
          def set_length(self, length):
              self.length = length
              self.update_taps()
              self.zi_r = np.zeros(len(self.taps)-1, dtype=np.float32)
              self.zi_i = np.zeros(len(self.taps)-1, dtype=np.float32)

          def set_sinc_exp(self, sinc_exp):
              self.sinc_exp = sinc_exp
              self.update_taps()

          def set_sinc_gain(self, sinc_gain):
              self.sinc_gain = sinc_gain
              self.update_taps()

          def set_sinc_ratio(self, sinc_ratio):
              self.sinc_ratio = sinc_ratio
              self.update_taps()

          def work(self, input_items, output_items):
              x = input_items[0]
              y_r, self.zi_r = lfilter(self.taps, 1.0, x.real, zi=self.zi_r)
              y_i, self.zi_i = lfilter(self.taps, 1.0, x.imag, zi=self.zi_i)
              output_items[0][:] = y_r + 1j * y_i
              return len(output_items[0])
    length: '91'
    sinc_exp: '1.0'
    sinc_gain: '110'
    sinc_ratio: '0.125'
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[ 3.45379446e-06, -7.44373709e-06, 1.99382256e-05, -4.25078410e-05, 7.77895351e-05, -1.29448329e-04, 2.02125473e-04, -3.01367617e-04, 4.33530620e-04, -6.05651323e-04, 8.25279728e-04, -1.10026470e-03, 1.43848622e-03, -1.84752771e-03, 2.33428252e-03, -2.90448953e-03, 3.56219121e-03, -4.30910950e-03, 5.14393070e-03, -6.06148940e-03, 7.05183452e-03, -8.09915382e-03, 9.18051571e-03, -1.02643725e-02, 1.13087301e-02, -1.22588495e-02, 1.30442672e-02, -1.35748140e-02, 1.37351298e-02, -1.33769015e-02, 1.23075641e-02, -1.02734459e-02, 6.93396394e-03, -1.82104185e-03, -5.72659762e-03, 1.66732917e-02, -3.24770538e-02, 5.54343300e-02, -8.93342343e-02, 1.40769976e-01, -2.21934464e-01, 3.56985825e-01, -5.97442725e-01, 1.06000478e+00, -1.99968683e+00, 3.63384209e+00, -1.99968683e+00, 1.06000478e+00, -5.97442725e-01, 3.56985825e-01, -2.21934464e-01, 1.40769976e-01, -8.93342343e-02, 5.54343300e-02, -3.24770538e-02, 1.66732917e-02, -5.72659762e-03, -1.82104185e-03, 6.93396394e-03, -1.02734459e-02, 1.23075641e-02, -1.33769015e-02, 1.37351298e-02, -1.35748140e-02, 1.30442672e-02, -1.22588495e-02, 1.13087301e-02, -1.02643725e-02, 9.18051571e-03, -8.09915382e-03, 7.05183452e-03, -6.06148940e-03, 5.14393070e-03, -4.30910950e-03, 3.56219121e-03, -2.90448953e-03, 2.33428252e-03, -1.84752771e-03, 1.43848622e-03, -1.10026470e-03, 8.25279728e-04, -6.05651323e-04, 4.33530620e-04, -3.01367617e-04, 2.02125473e-04, -1.29448329e-04, 7.77895351e-05, -4.25078410e-05, 1.99382256e-05, -7.44373709e-06, 3.45379446e-06]'
    type: ccf
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17005
    timeout: '100'
    type: complex
    vlen: zmq_len
  states: {}

connections:
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [audio_source_0, '1', blocks_float_to_complex_0, '1']
- [blocks_correctiq_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_float_to_complex_0, '0', epy_block_1, '0']
- [blocks_float_to_complex_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']
- [epy_block_1, '0', blocks_correctiq_0, '0']
- [fir_filter_xxx_0, '0', blocks_correctiq_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
