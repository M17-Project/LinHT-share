options:
  parameters:
    author: Wojciech SP5WWP
    copyright: M17 Foundation 2025
    generate_options: no_gui
    id: som_mic_test
    output_language: python
    run_options: run
    title: SOM microphone capture test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: aud_src
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: wm8960audio
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: aud_src
    samp_rate: samp_rate
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_len
    type: float
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:17006
    timeout: '100'
    type: float
    vlen: zmq_len
  states: {}
- name: zmq_len
  id: parameter
  parameters:
    label: ZMQ packet length
    short_id: z
    type: intx
    value: '1024'
  states: {}

connections:
- [audio_source_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
